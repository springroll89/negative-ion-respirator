## firmware/sdkconfig.defaults
```kconfig
CONFIG_MQTT_ENABLED=y
CONFIG_BROKER_URL_FROM_STDIN=n
CONFIG_ESP_TLS_USING_MBEDTLS=y
```
